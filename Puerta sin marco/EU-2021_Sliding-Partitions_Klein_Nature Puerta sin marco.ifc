Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
Time: 2021-06-30T21:37:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 30 21:37:37 2021 * Host: MSI * Database: C:\Users\info\AppData\Local\Temp\{457684F1-9ED3-4532-A501-B8278D3E7253}\ifc * Database version: 5507 * Database creation date: Wed Jun 30 21:37:34 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 30 21:37:34 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 30 21:37:34 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm

# IfcBuildingElementProxy: Model Text:100mm Arial (4)
In: Level 1
Text(Type) - Bold: no; Italic: no; Text Font: Arial; Text Size: 100 mm
Other(Type) - Category: Generic Models; Family Name: Model Text
Identity Data(Type) - Type Name: 100mm Arial
Pset_BuildingElementProxyCommon - Reference: Model Text:100mm Arial
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 10 mm
Identity Data - Subcategory: Generic Models
Materials and Finishes - Material: Oak Wood
Other - Category: Generic Models; Family: Model Text: 100mm Arial; Family and Type: Model Text: 100mm Arial; Type: Model Text: 100mm Arial; Type Id: Model Text: 100mm Arial
Phasing - Phase Created: Nueva construcción
Name (Model Text:...) | Horizontal Align | Text
100mm Arial | Left | Central Door
100mm Arial | Center | Installation Type: Nature Frameless door
100mm Arial | Left | Door closing against the wall
100mm Arial | Left | Biparting sliding

# IfcCurtainWall: Curtain Wall:Klein - Nature - Frameless Interior Partition 1000 x 2500mm (6)
In: Level 1
Type - Construction - Function: Interior; Automatically Embed: no; Curtain Panel: 2019_Panel_Klein_Nature_Fixed: Fixed; Join Condition: Not Defined; Panel Max Height: 2500 mm; Panel Max Width: 1500 mm; Panel Min Height: 3000 mm; Panel Min Width: 800 mm
Type - Data - Finish: Varnished
Type - General - Contact: Klein Ibérica S.A.U; Warranty Content: https://www.klein-europe.com/downloads/certificados/en/garantia.pdf; Warranty Period: 5 years
Type - Green Building Properties - Atmospheric Acidification Per Unit: 0.27; ClimateChange-BiogenicPerUnit: 0.372; ClimateChange-FossilPerUnit: 0.421; ClimateChange-LandUseAndLandUseChangePerUnit: 0.209; Climate Change Per Unit: 42.7; DepletionOfAbioticResources-FossilFuelsPerUnit: 601; DepletionOfAbioticResources-MineralsAndMetalsPerUnit: 0.000255; EutrophicationAquaticMarinePerUnit: 0.045; EutrophicationTerrestrialPerUnit: 0.512; Life Cycle Phase: A1-A3; Stratospheric Ozone Layer Destruction Per Unit: 0.000004; Unit: Installation 4m; WaterConsumptionPerUnit: 26.4
Type - Horizontal Grid - Adjust for Mullion Size: yes; Layout: Maximum Spacing; Spacing: 2500 mm
Type - Horizontal Mullions - Border 1 Type: Rectangular Mullion: Klein_Nature_Profile-Bottom-Panel; Border 2 Type: Rectangular Mullion: Klein_Nature_Profile-Top-Panel
Type - Identity Data - Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: www.bimetica.com; BIM Element Issue Date: 17/06/2021; BIM Profile URL: https://bimetica.com/en/bim-object-klein-nature-frameless-interior-partition-mm-10153.html; BIMsupport: https://bimsupport.info/es/fabricantes/klein-iberica-bim/; CE Mark: no; Contact Email: klein@klein.es; Country of Sale: Worldwide; Description: NATURE: crea un frente acristalado que combina paneles de vidrio fijos y móviles mediante una guía de madera. Versátil y flexible, permite múltiples combinaciones y cuida todos los detalles.; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Creation of element.; License Number: XXX-XXXX9536; Manufacturer: Klein Ibérica S.A.U; Owner: Klein Ibérica S.A.U; Production Year: 2021; Product URL: https://www.klein-europe.com/nature/; Sales Representative Contact: klein@klein.es; Technical Information: https://tienda.klein-europe.com/pub/media/pdf/ficha_tecnica_nature.pdf; Technical Support Contact: productmg@klein.es; Telephone Contact: (+34) 935 760 108; Tender Text URL: https://tienda.klein-europe.com/sistema-nature; Type Name: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; URL: https://www.klein-europe.com/nature/; Version: RVT2019
Type - Other - Category: Walls; Family Name: Curtain Wall
Type - Phasing - Packaging Type: Cartboard tube
Type - Vertical Grid - Adjust for Mullion Size: yes; Layout: Maximum Spacing; Spacing: 1000 mm
Pset_CurtainWallCommon - Reference: Curtain Wall:Klein - Nature - Frameless Interior Partition 1000 x 2500mm; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: Klein Ibérica S.A.U; ProductionYear: 2021
Constraints - Base Constraint: Level: Level 1; Base is Attached: no; Base Offset: 0 mm; Related to Mass: no; Room Bounding: yes; Top Constraint: Level: Level 2; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2200 mm
Dimensions - Area: 8.8 m2; Length: 4000 mm
Horizontal Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 4
Other - Family: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family and Type: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Type: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Type Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm
Phasing - Phase Created: Nueva construcción
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Vertical Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 3
Name (Curtain Wall:Klein - Nature - Frameless Interior Partition 1000 x 2500mm:...)
2449
2461
2473
2493
2511
2523

# IfcDoor: Sliding Door (4)
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Glass, Aluminum, Anodized black
Type - Analytical Properties - Analytic Construction: <None>
Type - Construction - Function: Interior
Type - Dimensions - Bottom Offset: 15 mm; Exterior Offset: 0 mm; Interior Offset: 17.7 mm; Thickness: 12 mm; Top Offset: 42.6 mm
Type - Identity Data - Manufacturer: Klein; Model: Nature; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Mark: 23; Type Name: Sliding Door
Type - Materials and Finishes - Handle Material: Oak Wood; Material: Glass
Type - Other - Category: Doors; Family Name: 2019_EN_Panel_Klein_Nature_Single-Door
OverallHeight: 3705.5 mm; OverallWidth: 2711.99 mm
Constraints - Level: Level: Level 1; Closing Against the Wall: no; Central: no; Biparting Sliding: yes
Dimensions - Lateral Offset A: 0 mm; Area: 2.1055 m2; Glass Width: 1000 mm; Handle Distance: 65 mm; Height: 2105.5 mm; Lateral Offset: 60 mm; Stop: 55 mm; Volume: 0.027133 m3; Width: 1000 mm
Graphics - Handle Strip: no; Handle Bar: no
Other - Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Family and Type: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Type: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Type Id: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door
Phasing - Phase Created: Nueva construcción
Pset_DoorCommon - IsExternal: no; Reference: 2019_EN_Panel_Klein_Nature_Single-Door:Sliding Door
Pset_ManufacturerTypeInformation - Manufacturer: Klein
BaseQuantities - Area: 8.8 m2
Name (2019_EN_Panel_Klein_Nature_Single-Door:Sliding Door:...) | Opening Distance (mm) | Op (mm) | Opening | Mark
2476 | 0 | 1000 | 0 | 3
2478 | 0 | 1000 | 0 | 4
2526 | 885 | 0 | 1 | 7
2528 | 885 | 0 | 1 | 8

# IfcDoor: Sliding Door (4)
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no; Material: Glass, Aluminum, Anodized black, Oak Wood
Type - Analytical Properties - Analytic Construction: <None>
Type - Construction - Function: Interior
Type - Dimensions - Bottom Offset: 15 mm; Exterior Offset: 0 mm; Interior Offset: 17.7 mm; Thickness: 12 mm; Top Offset: 42.6 mm
Type - Identity Data - Manufacturer: Klein; Model: Nature; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Mark: 23; Type Name: Sliding Door
Type - Materials and Finishes - Handle Material: Oak Wood; Material: Glass
Type - Other - Category: Doors; Family Name: 2019_EN_Panel_Klein_Nature_Single-Door
OverallHeight: 3705.5 mm
Constraints - Level: Level: Level 1; Biparting Sliding: no
Dimensions - Area: 2.1055 m2; Glass Width: 1000 mm; Height: 2105.5 mm; Lateral Offset: 60 mm; Width: 1000 mm
Other - Family: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Family and Type: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Type: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door; Type Id: 2019_EN_Panel_Klein_Nature_Single-Door: Sliding Door
Phasing - Phase Created: Nueva construcción
Pset_DoorCommon - IsExternal: no; Reference: 2019_EN_Panel_Klein_Nature_Single-Door:Sliding Door
Pset_ManufacturerTypeInformation - Manufacturer: Klein
BaseQuantities - Area: 8.8 m2
Name (2019_EN_Panel_Klein_Nature_Single-Door:Sliding Door:...) | OverallWidth (mm) | Central = Handle Bar | Closing Against the Wall = Handle Strip | Handle Distance (mm) | Lateral Offset A (mm) | Op (mm) | Opening Distance (mm) | Stop (mm) | Volume (m3) | Opening | Mark
2455 | 2716.99 | yes | no | 50 | 60 | 60 | 900 | 35 | 0.0297195 | 1 | 1
2462 | 2711.99 | no | yes | 65 | 0 | 1000 | 0 | 55 | 0.027623 | 0 | 2
2499 | 2716.99 | yes | no | 50 | 60 | 1060 | 0 | 35 | 0.0297195 | 0 | 5
2512 | 2711.99 | no | yes | 65 | 0 | 0 | 885 | 55 | 0.027623 | 1 | 6

# IfcMember: Klein_Nature_Profile-Bottom-Panel (16)
In: Level 1
Type - ElementType: Klein_Nature_Profile-Bottom-Panel; PredefinedType: MEMBER
Type - Constraints - Angle: 0 deg; Offset: 20.3 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: 2019_Profile_Klein_Nature_Frame-Panel: Bottom Frame; Thickness: 23 mm
Type - Dimensions - Width on side 1: 15 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Klein_Nature_Profile-Bottom-Panel
Type - Materials and Finishes - Material: Oak Wood
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Material: Oak Wood
Constraints - Level: Level: Level 1
Dimensions - Area: 0.067635 m2; Length: 1000 mm; Volume: 0.000635 m3
Other - Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family: Rectangular Mullion: Klein_Nature_Profile-Bottom-Panel; Family and Type: Rectangular Mullion: Klein_Nature_Profile-Bottom-Panel; Type: Rectangular Mullion: Klein_Nature_Profile-Bottom-Panel; Type Id: Rectangular Mullion: Klein_Nature_Profile-Bottom-Panel
Phasing - Phase Created: Nueva construcción
Pset_MemberCommon - IsExternal: no; LoadBearing: yes; Reference: Rectangular Mullion:Klein_Nature_Profile-Bottom-Panel; Span: 1000 mm
BaseQuantities - Length: 4000 mm; CrossSectionArea: 8.8 m2
Name (Rectangular Mullion:Klein_Nature_Profile-Bottom-Panel:...)
2485
2486
2487
2488
2489
2490
2491
2492
2505
2506
2507
2535
2536
2537
2538
2539

# IfcMember: Klein_Nature_Profile-Top-Door (8)
In: Level 1
Type - ElementType: Klein_Nature_Profile-Top-Door; PredefinedType: MEMBER
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: 2019_Profile_Klein_Nature_Top-Door: Top Frame above Door; Thickness: 19.65 mm
Type - Dimensions - Width on side 1: -0.00000112259 mm; Width on side 2: 94.5 mm
Type - Identity Data - Type Name: Klein_Nature_Profile-Top-Door
Type - Materials and Finishes - Material: Oak Wood
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Material: Oak Wood
Constraints - Level: Level: Level 1
Dimensions - Area: 0.234953 m2; Length: 1000 mm; Volume: 0.0078032 m3
Other - Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family: Rectangular Mullion: Klein_Nature_Profile-Top-Door; Family and Type: Rectangular Mullion: Klein_Nature_Profile-Top-Door; Type: Rectangular Mullion: Klein_Nature_Profile-Top-Door; Type Id: Rectangular Mullion: Klein_Nature_Profile-Top-Door
Phasing - Phase Created: Nueva construcción
Pset_MemberCommon - IsExternal: no; LoadBearing: yes; Reference: Rectangular Mullion:Klein_Nature_Profile-Top-Door; Span: 1000 mm
BaseQuantities - Length: 4000 mm; CrossSectionArea: 8.8 m2
Name (Rectangular Mullion:Klein_Nature_Profile-Top-Door:...)
2460
2470
2483
2484
2504
2520
2533
2534

# IfcMember: Klein_Nature_Profile-Top-Panel (8)
In: Level 1
Type - ElementType: Klein_Nature_Profile-Top-Panel; PredefinedType: MEMBER
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: 2019_Profile_Klein_Nature_Top-Panel: Top Frame; Thickness: 19.65 mm
Type - Dimensions - Width on side 1: -0.00000112259 mm; Width on side 2: 94.5 mm
Type - Identity Data - Type Name: Klein_Nature_Profile-Top-Panel
Type - Materials and Finishes - Material: Oak Wood
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Material: Oak Wood
Constraints - Level: Level: Level 1
Dimensions - Area: 0.199731 m2; Length: 1000 mm; Volume: 0.008231 m3
Other - Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family: Rectangular Mullion: Klein_Nature_Profile-Top-Panel; Family and Type: Rectangular Mullion: Klein_Nature_Profile-Top-Panel; Type: Rectangular Mullion: Klein_Nature_Profile-Top-Panel; Type Id: Rectangular Mullion: Klein_Nature_Profile-Top-Panel
Phasing - Phase Created: Nueva construcción
Pset_MemberCommon - IsExternal: no; LoadBearing: yes; Reference: Rectangular Mullion:Klein_Nature_Profile-Top-Panel; Span: 1000 mm
BaseQuantities - Length: 4000 mm; CrossSectionArea: 8.8 m2
Name (Rectangular Mullion:Klein_Nature_Profile-Top-Panel:...)
2451
2458
2469
2472
2495
2502
2519
2522

# IfcMember: Klein_Nature_Profile-Top-Pocket (8)
In: Level 1
Type - ElementType: Klein_Nature_Profile-Top-Pocket; PredefinedType: MEMBER
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: 2019_Profile_Klein_Nature_Top-Pocket: Top Frame Pocket for Door; Thickness: 19.65 mm
Type - Dimensions - Width on side 1: -0.00000112259 mm; Width on side 2: 94.5 mm
Type - Identity Data - Type Name: Klein_Nature_Profile-Top-Pocket
Type - Materials and Finishes - Material: Oak Wood
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Material: Oak Wood
Constraints - Level: Level: Level 1
Dimensions - Area: 0.241869 m2; Length: 1000 mm; Volume: 0.0077192 m3
Other - Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Family: Rectangular Mullion: Klein_Nature_Profile-Top-Pocket; Family and Type: Rectangular Mullion: Klein_Nature_Profile-Top-Pocket; Type: Rectangular Mullion: Klein_Nature_Profile-Top-Pocket; Type Id: Rectangular Mullion: Klein_Nature_Profile-Top-Pocket
Phasing - Phase Created: Nueva construcción
Pset_MemberCommon - IsExternal: no; LoadBearing: yes; Reference: Rectangular Mullion:Klein_Nature_Profile-Top-Pocket; Span: 1000 mm
BaseQuantities - Length: 4000 mm; CrossSectionArea: 8.8 m2
Name (Rectangular Mullion:Klein_Nature_Profile-Top-Pocket:...)
2459
2471
2481
2482
2503
2521
2531
2532

# IfcPlate: Fixed (16)
In: Level 1
Type - ElementType: Fixed; PredefinedType: CURTAIN_PANEL; Material: Glass
Type - Analytical Properties - Analytic Construction: <None>
Type - Dimensions - Bottom Offset: 0 mm; Exterior Offset: 14.3 mm; Interior Offset: 0 mm; Lateral Offset: 0 mm; Panel Thickness: 12 mm; Top Offset: 7 mm
Type - Identity Data - Manufacturer: Klein; Model: Nature; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Name: Fixed
Type - Materials and Finishes - Material: Glass
Type - Other - Category: Curtain Panels; Family Name: 2019_Panel_Klein_Nature_Fixed
Constraints - Level: Level: Level 1
Dimensions - Area: 2.0905 m2; Height: 2090.5 mm; Volume: 0.02517 m3; Width: 1000 mm
Other - Family: 2019_Panel_Klein_Nature_Fixed: Fixed; Family and Type: 2019_Panel_Klein_Nature_Fixed: Fixed; Host Id: Curtain Wall: Klein - Nature - Frameless Interior Partition 1000 x 2500mm; Type: 2019_Panel_Klein_Nature_Fixed: Fixed; Type Id: 2019_Panel_Klein_Nature_Fixed: Fixed
Phasing - Phase Created: Nueva construcción
Pset_PlateCommon - IsExternal: no; Reference: 2019_Panel_Klein_Nature_Fixed:Fixed; LoadBearing: yes
Pset_ManufacturerTypeInformation - Manufacturer: Klein
Name (2019_Panel_Klein_Nature_Fixed:Fixed:...)
2450
2453
2457
2464
2466
2468
2474
2480
2494
2497
2501
2514
2516
2518
2524
2530
